SRC_URI = "git://github.com/google/protobuf.git"
